# Repository dmitchellspace/bad-habips

File README.md:

# bad-habips
Repository for the High Altitude Balloon Instrumentation Platform senior design project for the 2017-2018 school year at the Rochester Institute of Technology

## KiCad design PCB/Rev 1/DAQCS_Rev1.kicad_pcb

Parts:
J1: Pi0_1; 4-Pin_Molex_Horizontal
J2: Pi0_2; 4-Pin_Molex_Horizontal
J3: Pi0_3; 4-Pin_Molex_Horizontal
J4: To_Motor; 6-Pin_Molex_Horizontal
J5: To_Center_Board; 8-Pin_Molex_Horizontal
J6: Pi0_4; 4-Pin_Molex_Horizontal
J7: From_Motor; 4-Pin_Molex_Horizontal
J8: Main_Battery; TE-AMP-2PIN-Vertical
J9: Comms_SPI; 6-Pin_Molex_Horizontal
J10: Backup_Battery; TE-AMP-2PIN-Vertical
J11: External_Temp; 4-Pin_Molex_Horizontal
J12: Comms_I2C; 4-Pin_Molex_Horizontal
J13: Main_Monitoring; JST-XH-4PIN
J14: 2S_Primary_Batt; TE-AMP-2PIN-Vertical
J15: 2S_Backup_Batt; TE-AMP-2PIN-Vertical
J16: Programming; 4-Pin_Molex_Horizontal
J17: To_Balloon; TE-AMP-2PIN-Vertical
J18: Motor_Batt_Monitoring; JST-XH-7PIN
J19: PI 3 RESET; HEADER_1x2_BB
J21: Ethernet_Switch_PWR; 2-Pin_Molex_Horizontal
MH1, MH2, MH3, MH4: GND; Mounting_Hole_Eighth_Inch
Q1: NTD20N03L27T4G; DPAK
R1: 10k; R_0805_HandSoldering
R2: 2; RES-POWER-RIEDON-PF1262

Connections:
2S_Backup: J15.1; also elsewhere on the board
2S_Backup_IN: J10.1, J17.1; also elsewhere on the board
2S_Primary: J8.1, J14.1; also elsewhere on the board
+3.3V: J11.1, J12.1; also elsewhere on the board
+5V: J21.2; also elsewhere on the board
COMMS_CS: J9.1; also elsewhere on the board
COMMS_MISO: J9.3; also elsewhere on the board
COMMS_MOSI: J9.4; also elsewhere on the board
COMMS_SCLK: J9.2; also elsewhere on the board
CUTDOWN_EN: Q1.2 (G), R1.1; also elsewhere on the board
GND: J1.4, J2.4, J3.4, J4.5, J5.1, J6.4, J7.3, J8.2, J9.5, J10.2, J11.4, J12.4, J13.4, J14.2, J15.2, J16.3, J18.7, J19.2, J21.1, MH1.1, MH2.1, MH3.1, MH4.1, Q1.3 (S), R1.2; also elsewhere on the board
HOST_SCL: J12.2; also elsewhere on the board
HOST_SDA: J12.3; also elsewhere on the board
IMU_1_CS_AG: J5.8; also elsewhere on the board
IMU_1_CS_M: J5.7; also elsewhere on the board
IMU_MISO: J5.5; also elsewhere on the board
IMU_MOSI: J5.6; also elsewhere on the board
IMU_SCLK: J5.4; also elsewhere on the board
MBATT_C1: J13.3; also elsewhere on the board
MBATT_C2: J13.2; also elsewhere on the board
MBATT_C3: J13.1; also elsewhere on the board
MEAS_CURRENT: J7.1; also elsewhere on the board
MEAS_SPEED: J7.2; also elsewhere on the board
MOTOR_DIRECTION_5: J4.4; also elsewhere on the board
MOTOR_ENABLE_5: J4.3; also elsewhere on the board
MULTIPLEX_A0: J5.3; also elsewhere on the board
MULTIPLEX_A1: J5.2; also elsewhere on the board
unnamed: J17.2, R2.2
unnamed: Q1.1 (D), R2.1
PWM_CURRENT_CTRL: J4.2; also elsewhere on the board
PWM_SPEED_CTRL: J4.1; also elsewhere on the board
RESET_PI_1: J1.3; also elsewhere on the board
RESET_PI_2: J2.3; also elsewhere on the board
RESET_PI_3: J3.3; also elsewhere on the board
RESET_PI_4: J6.3; also elsewhere on the board
RPI3_RST: J19.1; also elsewhere on the board
RST_SBWTDIO_HOST: J16.2; also elsewhere on the board
RWBATT_C1: J18.6; also elsewhere on the board
RWBATT_C2: J18.5; also elsewhere on the board
RWBATT_C3: J18.4; also elsewhere on the board
RWBATT_C4: J18.3; also elsewhere on the board
RWBATT_C5: J18.2; also elsewhere on the board
RWBATT_C6: J18.1; also elsewhere on the board
SBWTCK_HOST: J16.1; also elsewhere on the board
TEENSY_SCL: J11.2; also elsewhere on the board
TEENSY_SDA: J11.3; also elsewhere on the board
UART_1_RX: J1.2; also elsewhere on the board
UART_1_TX: J1.1; also elsewhere on the board
UART_2_RX: J2.2; also elsewhere on the board
UART_2_TX: J2.1; also elsewhere on the board
UART_3_RX: J3.2; also elsewhere on the board
UART_3_TX: J3.1; also elsewhere on the board
UART_4_RX: J6.2; also elsewhere on the board
UART_4_TX: J6.1; also elsewhere on the board

Notes on the sheet:
Raspberry Pi Zeros
Comms Board
Programming
Battery & Power Connections
MSP-430 Interfaces
Cutdown Mechanism
Additional Schematic Drawings
Teensy 3.6 Interfaces
Motor
Sensors
PI 3 RST
3-Cell Batts
2-Cell Batteries
RW Battery
Mounting Holes
Network Switch PWR

Parts:
C1, C2, C4, C5, C6, C7, C10, C11: 10uF; C_0805_HandSoldering
C3, C8: 1uF; C_0805_HandSoldering
C9: 1nF; C_0805_HandSoldering
C12: 0.1uF; C_0805_HandSoldering
C13: 10pF; C_0805_HandSoldering
C14: 47uF; C_1210_HandSoldering
D1, D2, D6: SMAZ18-13-F; DO-214AC_Schottky
D3, D4: CDBA540-HF; DO-214AC_Schottky
D5: VLMG21J2M1-GS08; 2-SMT,J-Lead
D34: LTST-C171KRKT; LED_0805_HandSoldering
L1: NRS8040T6R8NJGJ
Q2, Q4, Q17: DMP3099L-7; SOT-23
Q3, Q18: NTR4003NT3G; SOT-23
R3: 10; R_0805_HandSoldering
R4, R6, R63, R64: 10k; R_0805_HandSoldering
R5, R8, R9: 10m; R_0805_HandSoldering
R7: 100k; R_0805_HandSoldering
R10: 40.2k; R_0805_HandSoldering
R11: 3.57k; R_0805_HandSoldering
R12: 10.5k; R_0805_HandSoldering
R13: 7.5k; R_0805_HandSoldering
R14: 11.8k; R_0805_HandSoldering
R15: 261k; R_0805_HandSoldering
R16: 35.7k; R_0805_HandSoldering
R60: 330; R_0805_HandSoldering
R62: 910; R_0805_HandSoldering
SW2, SW4: SWITCH_DPDT; SWITCH-DPDT-SLIDE-5A
U1: LTC2992; DFN-16-1EP_3x4mm_Pitch0.45mm
U2, U3: AZ2117H; SOT223
U4: LT8609; MSOP-10_3x3mm_Pitch0.5mm_With_Center_Pad

Connections:
2S_Backup: SW2.5; also elsewhere on the board
2S_Backup_IN: C1.1, D2.2 (K), Q4.3 (S), SW2.6; also elsewhere on the board
2S_Primary: C2.1, D1.2 (K), Q2.3 (S), R4.1; also elsewhere on the board
+3.3V: C11.1, R13.1, U3.2 (Output); also elsewhere on the board
+5V: C6.1, R3.2, R8.1, R64.1, U1.16 (Sense2-), U3.3 (Input); also elsewhere on the board
+6.5V: C5.1, C13.1, C14.1, L1.2, R15.2, SW2.1, SW4.2, U2.3 (Input); also elsewhere on the board
ALERT: U1.13 (GPIO4); also elsewhere on the board
Backup_Batt_EN: Q18.2 (G), R64.2; also elsewhere on the board
Backup_CTRL: D3.1, Q17.1 (D)
Backup_PMOS: D6.2 (K), Q4.1 (D), Q17.3 (S), R63.1
Battery_Power: R5.1, SW2.2, U1.1 (Sense1-); also elsewhere on the board
Data_Rdy: U1.4 (GPIO3); also elsewhere on the board
From_Batt: C4.1, D3.2, D4.2, SW4.5; also elsewhere on the board
From_LDO: C10.1, R8.2, R11.1, U1.15 (Sense2+), U2.2 (Output); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C14.2, D5.1 (K), D34.1 (K), Q3.3 (S), Q18.3 (S), R6.2, R7.2, R10.2, R12.2, R14.2, R16.2, U1.3 (GPIO1), U1.5 (ADR1), U1.6 (ADR0), U1.12 (GND), U1.14 (GPIO2), U1.17 (PAD), U4.5 (SYNC), U4.11 (GND); also elsewhere on the board
Main_Batt_EN: Q3.2 (G), R6.1; also elsewhere on the board
unnamed: C3.1, R3.1, U1.7 (INTVcc), U1.8 (VDD)
unnamed: C7.1, R9.1, U4.9 (Vin), U4.10 (EN/UV)
unnamed: C8.1, U4.3 (INTVcc)
unnamed: C9.1, U4.7 (TR/SS)
unnamed: C12.1, L1.1, U4.2 (SW)
unnamed: C12.2, U4.1 (BST)
unnamed: D1.1 (A), Q2.2 (G), Q3.1 (D), R4.2
unnamed: D2.1 (A), D4.1, Q2.1 (D), Q4.2 (G), R7.1
unnamed: D5.2 (A), R62.2
unnamed: D6.1 (A), Q17.2 (G), Q18.1 (D), R63.2
unnamed: D34.2 (A), R60.1
unnamed: R10.1, U4.4 (RT)
unnamed: R11.2, R12.1, U2.1 (ADJ/GND)
unnamed: R13.2, R14.1, U3.1 (ADJ/GND)
unnamed: R60.2, SW2.4
unnamed: R62.1, SW4.1
SW_IN: R9.2, SW2.3
Switch_FB: C13.2, R15.1, R16.1, U4.6 (FB)
TEENSY_SCL: U1.9 (SCL); also elsewhere on the board
TEENSY_SDA: U1.10 (SDAI), U1.11 (SDA0); also elsewhere on the board
To_Meas_Current: R5.2, SW4.6, U1.2 (Sense1+)

Notes on the sheet:
The system is initially powered off of the backup battery but then switches to the main battery during the initialization sequence by toggling the "Batt_EN" GPIO high
Battery Input and Switchover
DC-DC Regulators
The AZ2117 is compatible with low ESR ceramic capacitor. The ESR of the output capacitors must be less than 20Ω. A minimum of 1µF output capacitor is required.
Select between 3S and 2S batteries
Current Measurement

Parts:
C15: 1uF; C_0805_HandSoldering
C16: 1F; CP_Radial_D21.5mm_P5.00mm_Supercapacitor
C33: 1000pF; C_0805_HandSoldering
D9: APT2012LZGCK; LED_0805_HandSoldering
D10: HSMR-C170; LED_0805_HandSoldering
D11: SBRT5A50SA-13; DO-214AC_Schottky
D16: LTST-C171KRKT; LED_0805_HandSoldering
Q5, Q6, Q7, Q8, Q9: NTR4003NT3G; SOT-23
R17: 681k; R_0805_HandSoldering
R18, R21, R24: 102k; R_0805_HandSoldering
R19: 107k; R_0805_HandSoldering
R20, R23: 41.2k; R_0805_HandSoldering
R22, R25, R29, R32: 10.2k; R_0805_HandSoldering
R26: 75k; R_0805_HandSoldering
R27: 13.7k; R_0805_HandSoldering
R28: 18.7k; R_0805_HandSoldering
R30, R33: 43.2k; R_0805_HandSoldering
R31, R34: 15k; R_0805_HandSoldering
R35: 10; R_0805_HandSoldering
R36: 1.2k; R_0805_HandSoldering
R37: 10kR; R_0805_HandSoldering
R38, R40, R41, R43, R44, R45, R61: 10k; R_0805_HandSoldering
R39: 80; R_0805_HandSoldering
R42: 150; R_0805_HandSoldering
SW3: PTS645SM43SMTR92 LFS; SWITCH-TACTILE-PTS645SM43SMTR92
U5: Teensy3.6; Teensy33_SidePinsAndVBatt

Connections:
+3.3V: D11.1 (A), Q7.2 (G), Q8.2 (G), R37.1, R38.1, R41.2, R45.2, R61.1; also elsewhere on the board
+5V: D9.2 (A), D10.2 (A), D16.2 (A), R35.2, R40.1, R43.1, R44.1; also elsewhere on the board
ALERT: U5.4 (2_PWM); also elsewhere on the board
Backup_Batt_EN: U5.8 (6_PWM); also elsewhere on the board
CELL1: R22.1, R31.1, U5.35 (38_A19_PWM_SDA1); also elsewhere on the board
CELL2: R21.1, R30.1, U5.34 (37_A18_PWM_SCL1); also elsewhere on the board
CELL3: R20.1, R29.1, U5.33 (36_A17_PWM); also elsewhere on the board
CELL4: R19.1, R28.1, U5.32 (35_A16_PWM); also elsewhere on the board
CELL5: R18.1, R27.1, U5.31 (34_A15_CAN1TX_sda0); also elsewhere on the board
CELL6: R17.1, R26.1, U5.30 (33_A14_CAN1TX_scl0); also elsewhere on the board
DAQCS_CS: U5.23 (31_A12_RX4_CS1); also elsewhere on the board
DAQCS_MISO: U5.3 (1_TX1_MISO1_Touch); also elsewhere on the board
DAQCS_MOSI: U5.2 (0_RX1_MOSI1_Touch); also elsewhere on the board
DAQCS_SCLK: U5.24 (32_A13_TX4_SCK1); also elsewhere on the board
Data_Rdy: U5.12 (10_PWM_TX2_CS0); also elsewhere on the board
GND: C15.2, C16.2, C33.1, Q5.2 (S), Q6.2 (S), Q9.2 (S), R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, SW3.1, U5.1 (GND), U5.39 (GND), U5.52 (AGND); also elsewhere on the board
IMU_1_CS_AG: U5.18 (26_tx1); also elsewhere on the board
IMU_1_CS_M: U5.19 (27_rx1); also elsewhere on the board
IMU_CS_AG: U5.11 (9_PWM_RX2_CS0); also elsewhere on the board
IMU_CS_M: U5.21 (29_PWM_can0tx_Touch); also elsewhere on the board
IMU_MISO: U5.14 (12_MISO0); also elsewhere on the board
IMU_MOSI: U5.13 (11_MOSI0); also elsewhere on the board
IMU_SCLK: U5.41 (14_A0_PWM_sck0); also elsewhere on the board
MBATT_C1: R25.2; also elsewhere on the board
MBATT_C2: R24.2; also elsewhere on the board
MBATT_C3: R23.2; also elsewhere on the board
MCELL1: R25.1, R34.1, U5.36 (39_A20); also elsewhere on the board
MCELL2: R24.1, R33.1, U5.37 (A21_DAC0); also elsewhere on the board
MCELL3: R23.1, R32.1, U5.38 (A22_DAC1); also elsewhere on the board
MEAS_CURRENT: U5.43 (16_A2_scl0_Touch); also elsewhere on the board
MEAS_SPEED: U5.42 (15_A1_CS0_Touch); also elsewhere on the board
MOTOR_DIRECTION: Q8.3 (S), R38.2, U5.10 (8_TX3_miso0_sda0)
MOTOR_DIRECTION_5: Q8.1 (D), R44.2; also elsewhere on the board
MOTOR_ENABLE: Q7.3 (S), R37.2, U5.9 (7_RX3_miso0_scl0)
MOTOR_ENABLE_5: Q7.1 (D), R43.2; also elsewhere on the board
MSP_GPIO_0: U5.47 (20_A6_PWM_CS0_sck1); also elsewhere on the board
MSP_GPIO_1: U5.48 (21_A7_PWM_CS0_sck1); also elsewhere on the board
MSP_GPIO_2: U5.49 (22_A8_PWM_Touch); also elsewhere on the board
MSP_GPIO_3: U5.50 (23_A9_PWM_Touch); also elsewhere on the board
Main_Batt_EN: U5.20 (28); also elsewhere on the board
unnamed: D9.1 (K), R36.2
unnamed: D10.1 (K), R39.2
unnamed: D16.1 (K), R42.2
unnamed: Q5.3 (D), R36.1
unnamed: Q6.3 (D), R39.1
unnamed: Q9.3 (D), R42.1
PWM_CURRENT_CTRL: U5.22 (30_PWM_can0rx_Touch); also elsewhere on the board
PWM_SPEED_CTRL: U5.44 (17_A3_sda0_Touch); also elsewhere on the board
RPI3_RST: U5.7 (5_PWM_tx1_miso1); also elsewhere on the board
RTC_PWR: C16.1, D11.2 (K), U5.25 (VBat)
RWBATT_C1: R22.2; also elsewhere on the board
RWBATT_C2: R21.2; also elsewhere on the board
RWBATT_C3: R20.2; also elsewhere on the board
RWBATT_C4: R19.2; also elsewhere on the board
RWBATT_C5: R18.2; also elsewhere on the board
RWBATT_C6: R17.2; also elsewhere on the board
TEENSY_BUTTON: C33.2, R61.2, SW3.2, U5.45 (18_A4_SDA0_Touch)
TEENSY_LED_BLUE: Q6.1 (G), U5.17 (25)
TEENSY_LED_GREEN: Q5.1 (G), U5.16 (24)
TEENSY_LED_RED: Q9.1 (G), R40.2, U5.46 (19_A5_SCL0_Touch)
TEENSY_PWR_IN: C15.1, R35.1, U5.53 (Vin)
TEENSY_SCL: R41.1, U5.5 (3_PWM_CAN0TX_SCL2); also elsewhere on the board
TEENSY_SDA: R45.1, U5.6 (4_PWM_CAN0RX_SDA2); also elsewhere on the board

Notes on the sheet:
Filtering
I2C Pullup
Battery Cell Analog Inputs
Teensy 3.6
LEDs
Level Shifting
RTC
Button

Parts:
D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: MMQA5V6T1G; SC-74
U10, U11, U12: AOZ8318DI; DFN-10-CenterPad
W1, W2, W3, W6, W7, W12, W13, W14, W17, W18, W21, W23, W24, W27, W28, W29, W32, W34, W35, W38, W39, W43, W45, W46, W49, W50, W54, W55, W56, W57, W60, W61, W65: TEST_1P; PINTST

Connections:
2S_Backup_IN: W17.1; also elsewhere on the board
2S_Primary: W6.1; also elsewhere on the board
+3.3V: D24.6, D30.6, W29.1; also elsewhere on the board
+5V: W18.1; also elsewhere on the board
+6.5V: W61.1; also elsewhere on the board
Backup_Batt_EN: D26.3; also elsewhere on the board
Battery_Power: W50.1; also elsewhere on the board
CELL1: U11.9 (CH2); also elsewhere on the board
CELL2: U11.7 (CH4); also elsewhere on the board
CELL3: U11.3 (CH3); also elsewhere on the board
CELL4: U11.1 (CH1); also elsewhere on the board
CELL5: U12.7 (CH4); also elsewhere on the board
CELL6: U12.3 (CH3); also elsewhere on the board
COMMS_CS: D23.4, W57.1; also elsewhere on the board
COMMS_MISO: D23.3, W35.1; also elsewhere on the board
COMMS_MOSI: D23.1, W24.1; also elsewhere on the board
COMMS_SCLK: D23.6, W46.1; also elsewhere on the board
CUTDOWN_EN: W55.1; also elsewhere on the board
From_Batt: W39.1; also elsewhere on the board
From_LDO: W7.1; also elsewhere on the board
GND: D19.2, D19.4, D19.5, D20.2, D20.4, D20.5, D21.2, D21.4, D21.5, D22.2, D22.4, D22.5, D23.2, D23.5, D24.2, D24.4, D24.5, D25.2, D25.3, D25.4, D25.5, D26.2, D26.4, D26.5, D26.6, D27.2, D27.3, D27.5, D28.2, D28.5, D29.2, D29.5, D30.2, D30.4, D30.5, U10.11 (GND), U11.11 (GND), U12.11 (GND); also elsewhere on the board
HOST_SCL: D30.1, W3.1; also elsewhere on the board
HOST_SDA: D30.3, W14.1; also elsewhere on the board
IMU_1_CS_AG: D28.1; also elsewhere on the board
IMU_1_CS_M: D28.3; also elsewhere on the board
IMU_MISO: D28.6; also elsewhere on the board
IMU_MOSI: D28.4; also elsewhere on the board
IMU_SCLK: D27.1; also elsewhere on the board
MCELL1: U10.1 (CH1); also elsewhere on the board
MCELL2: U10.3 (CH3); also elsewhere on the board
MCELL3: U10.9 (CH2); also elsewhere on the board
MEAS_CURRENT: U12.9 (CH2); also elsewhere on the board
MEAS_SPEED: U12.1 (CH1); also elsewhere on the board
MOTOR_DIRECTION_5: D29.3, W27.1; also elsewhere on the board
MOTOR_ENABLE_5: D29.6, W38.1; also elsewhere on the board
MULTIPLEX_A0: D27.6, W49.1; also elsewhere on the board
MULTIPLEX_A1: D27.4, W60.1; also elsewhere on the board
Main_Batt_EN: W28.1; also elsewhere on the board
PWM_CURRENT_CTRL: D29.4; also elsewhere on the board
PWM_SPEED_CTRL: D29.1; also elsewhere on the board
RESET_PI_1: D19.3, W21.1; also elsewhere on the board
RESET_PI_2: D20.3, W32.1; also elsewhere on the board
RESET_PI_3: D21.1, W43.1; also elsewhere on the board
RESET_PI_4: D22.3, W54.1; also elsewhere on the board
RPI3_RST: D26.1, W65.1; also elsewhere on the board
RST_SBWTDIO_HOST: D25.6; also elsewhere on the board
SBWTCK_HOST: D25.1; also elsewhere on the board
TEENSY_SCL: D24.1; also elsewhere on the board
TEENSY_SDA: D24.3; also elsewhere on the board
UART_1_RX: D19.6, W12.1; also elsewhere on the board
UART_1_TX: D19.1, W1.1; also elsewhere on the board
UART_2_RX: D20.6, W34.1; also elsewhere on the board
UART_2_TX: D20.1, W23.1; also elsewhere on the board
UART_3_RX: D21.6, W56.1; also elsewhere on the board
UART_3_TX: D21.3, W45.1; also elsewhere on the board
UART_4_RX: D22.6, W13.1; also elsewhere on the board
UART_4_TX: D22.1, W2.1; also elsewhere on the board
