# Repository dmitchellspace/bad-habips (continued)

## KiCad design PCB/Rev 1/DAQCS_Rev1.kicad_pcb (continued)

Parts:
C17: 10000pF; C_0805_HandSoldering
C18: 10uF; C_0805_HandSoldering
C20: 100nF; C_0805_HandSoldering
C22: 0.1uF; C_0805_HandSoldering
R47, R48: 10; R_0805_HandSoldering
U6: LSM9DS1; PQFN24P43_350X300X102L35X23N
U7: BME280

Connections:
+3.3V: R47.1, R48.2; also elsewhere on the board
GND: C17.2, C18.2, C20.2, C22.2, U6.14 (RES), U6.15 (RES), U6.16 (RES), U6.17 (RES), U6.18 (RES), U6.19 (GND), U6.20 (GND), U7.1 (GND), U7.5 (SDO), U7.7 (GND); also elsewhere on the board
IMU_CS_AG: U6.7 (CS_A/G); also elsewhere on the board
IMU_CS_M: U6.8 (CS_M); also elsewhere on the board
IMU_MISO: U6.5 (SDO_A/G), U6.6 (SDO_M); also elsewhere on the board
IMU_MOSI: U6.4 (SDA/SDI/SDO); also elsewhere on the board
IMU_SCLK: U6.2 (SCL/SPC); also elsewhere on the board
LSM_C1: C20.1, U6.24 (C1)
LSM_CAP: C17.1, U6.21 (CAP)
unnamed: C18.1, R47.2, U6.1 (VDDIO), U6.3 (VDDIO), U6.22 (VDD), U6.23 (VDD)
unnamed: C22.1, R48.1, U7.2 (CSB), U7.6 (VDDIO), U7.8 (VDD)
TEENSY_SCL: U7.4 (SCK); also elsewhere on the board
TEENSY_SDA: U7.3 (SDI); also elsewhere on the board

Notes on the sheet:
IMU
Temp, Pressure, Humidity Msmt

Parts:
C23, C27, C28, C29: 100nF; C_0805_HandSoldering
C24: 1000pF; C_0805_HandSoldering
C25: 1uF; C_0805_HandSoldering
C26: 10uF; C_0805_HandSoldering
C30, C31: 22pF; C_0805_HandSoldering
C32: 10000pF; C_0805_HandSoldering
D7: APT2012LZGCK; LED_0805_HandSoldering
D8: HSMR-C170; LED_0805_HandSoldering
D31: LTST-C171KRKT; LED_0805_HandSoldering
Q12, Q14, Q15: NTR4003NT3G; SOT-23
R46, R51, R52, R53: 10k; R_0805_HandSoldering
R49, R59: 10; R_0805_HandSoldering
R50: 0; R_0805_HandSoldering
R54: 1.2k; R_0805_HandSoldering
R55: 80; R_0805_HandSoldering
R57: 150; R_0805_HandSoldering
SW1: PTS645SM43SMTR92 LFS; SWITCH-TACTILE-PTS645SM43SMTR92
U8: MSP430FR5994; LQFP-80_12x12mm_Pitch0.5mm
U9: ASEMB-24MHZ-XY-T; ASEMB-24MHZ
Y1: 32.768 kHz; 32.768_Crystal_ThroughHole

Connections:
+3.3V: C25.1, C26.1, C27.1, C28.1, C29.1, R49.2, R51.2, R52.2, R53.1, R59.1; also elsewhere on the board
+5V: D7.2 (A), D8.2 (A), D31.2 (A), R46.1; also elsewhere on the board
COMMS_CS: U8.56 (P5.3_UCB1STE); also elsewhere on the board
COMMS_MISO: U8.54 (P5.1_UCB1SOMI_UCB1SCL); also elsewhere on the board
COMMS_MOSI: U8.53 (P5.0_UCB1SIMO_UCB1SDA); also elsewhere on the board
COMMS_SCLK: U8.55 (P5.2_UCB1CLK_TA4CLK); also elsewhere on the board
CUTDOWN_EN: U8.31 (P4.0_A8); also elsewhere on the board
DAQCS_CS: U8.16 (P1.3_TA1.2_UCB0STE_A3_C3); also elsewhere on the board
DAQCS_MISO: U8.52 (P1.7_TB0.4_UCB0SOMI_UCB0SCL_TA1.0); also elsewhere on the board
DAQCS_MOSI: U8.51 (P1.6_TB0.3_UCB0SIMO_UCB0SDA_TA0.0); also elsewhere on the board
DAQCS_SCLK: U8.43 (P2.2_TB0.2_UCB0CLK); also elsewhere on the board
GND: C23.2, C24.1, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, Q12.2 (S), Q14.2 (S), Q15.2 (S), SW1.1, U8.19 (DVSS2), U8.39 (DVSS3), U8.60 (DVSS1), U8.73 (AVSS3), U8.76 (AVSS2), U8.79 (AVSS1), U9.2 (GND); also elsewhere on the board
HF_IN_1: U8.74 (PJ.6_HFXIN), U9.3 (Output)
HOST_SCL: R51.1, U8.14 (P7.1_UCB2SOMI_UCB2SCL); also elsewhere on the board
HOST_SDA: R52.1, U8.13 (P7.0_UCB2SIMO_UCB2SDA); also elsewhere on the board
LF_IN: C30.1, U8.77 (PJ.4_LFXIN), Y1.2
LF_OUT: C31.1, U8.78 (PJ.5_LFXOUT), Y1.1
MSP_GPIO_0: U8.15 (P8.0); also elsewhere on the board
MSP_GPIO_1: U8.44 (P8.1); also elsewhere on the board
MSP_GPIO_2: U8.45 (P8.2); also elsewhere on the board
MSP_GPIO_3: U8.46 (P8.3); also elsewhere on the board
MSP_LED_BLUE: Q15.1 (G), U8.2 (P1.1_TA0.2_TA1CLK_COUT_A1_C1_VREF+_VERE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)
MSP_LED_GREEN: Q12.1 (G), U8.1 (P1.0_TA0.1_DMAE0_RTCCLK_A0_C0_VREF-_VER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)
MSP_LED_RED: Q14.1 (G), R46.2, U8.3 (P1.2_TA1.1_TA0CLK_COUT_A2_C2)
MULTIPLEX_A0: U8.17 (P1.4_TB0.1_UCA0STE_A4_C4); also elsewhere on the board
MULTIPLEX_A1: U8.18 (P1.5_TB0.2_UCA0CLK_A5_C5); also elsewhere on the board
unnamed: C23.1, R49.1, R50.2, U8.20 (DVCC2), U8.40 (DVCC3), U8.61 (DVCC1)
unnamed: C32.1, R59.2, U9.4 (VDD)
unnamed: D7.1 (K), R54.2
unnamed: D8.1 (K), R55.2
unnamed: D31.1 (K), R57.2
unnamed: Q12.3 (D), R54.1
unnamed: Q14.3 (D), R57.1
unnamed: Q15.3 (D), R55.1
unnamed: R50.1, U8.80 (AVCC1)
RESET_PI_1: U8.57 (P4.4_TB0.5); also elsewhere on the board
RESET_PI_2: U8.58 (P4.5); also elsewhere on the board
RESET_PI_3: U8.59 (P4.6); also elsewhere on the board
RESET_PI_4: U8.12 (P4.7); also elsewhere on the board
RST_SBWTDIO_HOST: C24.2, R53.2, SW1.2, U8.38 (RST_NMI_SBWTDIO_N); also elsewhere on the board
SBWTCK_HOST: U8.37 (TEST_SBWTCK); also elsewhere on the board
UART_1_RX: U8.42 (P2.1_TB0.0_UCA0RXD_UCA0SOMI); also elsewhere on the board
UART_1_TX: U8.41 (P2.0_TB0.6_UCA0TXD_UCA0SIMO_TB0CLK_ACLK); also elsewhere on the board
UART_2_RX: U8.36 (P2.6_TB0.1_UCA1RXD_UCA1SOMI); also elsewhere on the board
UART_2_TX: U8.35 (P2.5_TB0.0_UCA1TXD_UCA1SIMO); also elsewhere on the board
UART_3_RX: U8.66 (P5.5_UCA2RXD_UCA2SOMI_ACLK); also elsewhere on the board
UART_3_TX: U8.65 (P5.4_UCA2TXD_UCA2SIMO_TB0OUTH); also elsewhere on the board
UART_4_RX: U8.9 (P6.1_UCA3RXD_UCA3SOMI); also elsewhere on the board
UART_4_TX: U8.8 (P6.0_UCA3TXD_UCA3SIMO); also elsewhere on the board

Notes on the sheet:
Layout: Place decoupling capacitor as close to pins as possible
Host MSP430 Pinout
DC Filtering
Low-Freq. Oscillator
High-Freq. Oscillator
I2C Pullup
Reset
LEDs

Board: 4 copper layers, 102.0 x 108.0 mm, 208 parts (0 on the bottom side), 135 nets.

File PCB/Documentation/MainBoardV2_BOM.xlsx (part):

RIT MSD P18104: Bad Habips - High Altitute Balloon Instrumentation Platform Mai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
Ref | Description | Manf Part Number | Manf | Footprint | Purchase Link | Quantity | Price | Sub Total
C1, C2, C4, C5, C6, C7, C10, C11, C26 | 10uF, 25V | GRM21BR61E106MA73L | Murata | 0805(2012 Metric) | Digikey | 9 | 0.21 | 1.89
C3, C8, C15, C25 | 1uF, 16V | CL21B105KOFNNNG | Samsung | 0805(2012 Metric) | Digikey | 4 | 0.1 | 0.4
C9, C24, C33 | 1nF | C0805C102K5RACTU | Kemet | 0805(2012 Metric) | Digikey | 3 | 0.1 | 0.30000000000000004
C12, C18, C20, C22, C23, C27, C28, C29 | 0.1uF, 16V | ECP-U1C104MA5 | Panasonic | 0805(2012 Metric) | Digikey | 8 | 0.66 | 5.28
C13 | 10pF, 50V | CC0805JRNPO9BN100 | Yageo | 0805(2012 Metric) | Digikey | 1 | 0.1 | 0.1
C14 | 47uF, 16V | EMK325BJ476MM-P | Taiyo Yuden | 1210 (3225 Metric) | Digikey | 1 | 0.71 | 0.71
C16 | 1F, 5.5V | KR-5R5C105-R | Eaton | Through-Hole | Digikey | 1 | 2.72 | 2.72
C17, C32 | 10000pF, 16V | ECH-U1C103JX5 | Panasonic | 0805(2012 Metric) | Digikey | 2 | 0.46 | 0.92
C30, C31 | 22pF | C0805C220J5GACTU | Kemet | 0805(2012 Metric) | Digikey | 2 | 0.1 | 0.2
D1, D2, D6 | 18V, 1W Zener | SMAZ18-13-F | Diodes Inc | DO-214AC | Digikey | 3 | 0.5 | 1.5
D3, D4, D11 | 40V, 5A Schottky | CDBA540-HF | Comchip | DO-214AC | Digikey | 3 | 0.49 | 1.47
D5 | Green LED | VLMG21J2M1-GS08 | Vishay | 2-SMD, J-Lead | Digikey | 1 | 0.47 | 0.47
D7, D9 | Green LED | APT2012LZGCK | Kingbright | 0805(2012 Metric) | Digikey | 2 | 0.61 | 1.22
D8, D10 | Blue LED | HSMR-C170 | Broadcom | 0805(2012 Metric) | Digikey | 2 | 0.89 | 1.78
D16, D31, D34 | Red LED | LTST-C171KRKT | Lite-On | 0805(2012 Metric) | Digikey | 3 | 0.31 | 0.92999999999999994
D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30 | TVS Diodes | MMQA5V6T1G | On Semi | SC-74 | Digikey | 12 | 0.318 | 3.8159999999999998
J1, J2, J3, J6, J7, J11, J12, J16 | 4POS 3MM Micro-Fit 3.0 Horizontal | 0430450400 | Molex | Custom Through-Hole | Digikey | 8 | 1.35 | 10.8
Mates for Above | 4POS 3MM Mating Micro-Fit 3.0 | 43025-0400 | Molex | In-Line | Digikey | 8 | 0.4 | 3.2
J4, J9 | 6POS 3MM Micro-Fit 3.0 Horizontal | 0430450600 | Molex | Custom Through-Hole | Digikey | 2 | 1.71 | 3.42
Mates for Above | 6POS 3MM Mating Micro-Fit 3.0 | 43025-0600 | Molex | In-Line | Digikey | 2 | 0.43 | 0.86
J5 | 8POS 3MM Micro-Fit 3.0 Horizontal | 0430450800 | Molex | Custom Through-Hole | Digikey | 1 | 2.09 | 2.09
Mates for Above | 8POS 3MM Mating Micro-Fit 3.0 | 43025-0800 | Molex | In-Line | Digikey | 1 | 0.49 | 0.49
J8, J10, J14, J15, J17 | 2POS Right Angle Vertical | 1586041-2 | TE Connect. | Custom Through-Hole | Digikey | 5 | 0.7 | 3.5
Mates for Above | CONN RCPT HOUSING 2POS 4.2MM | 1586019-2 | TE Connect. | In-Line | Digikey | 5 | 0.21 | 1.05
J13 | 4POS JST-PH Vertical 2.54mm | 4330589508 | WGCD | 2.54MM Header | Amazon | 1 | 9.7899999999999991 | 9.7899999999999991
J18 | 7POS JST-PH Vertical 2.54mm | 4330589508 | WGCD | 2.54MM Header
Mates for Above | Kit included mates and pins | 4330589508 | WGCD | In-Line
J21 | 2POS 3MM Micro-Fit 3.0 Horizontal | 0436500200 | Molex | Custom Through-Hole | Digikey | 1 | 0.91 | 0.91
Mates for Above | 2POS 3MM Mating Micro-Fit 3.0 | 43645-0200 | Molex | In-Line | Digikey | 1 | 0.31 | 0.31
TE Pins | Mating Pins for TE Connector | 1586315-1 | TE Connect. | In-Line | Digikey | 50 | 4.5199999999999997E-2 | 2.2599999999999998
Molex Pins | Mating pins for Molex Connectors | 43030-0001 | Molex | In-Line | Digikey | 100 | 8.3900000000000002E-2 | 8.39
J19 | Headers - 1x2 | B01MQ48T2V | OCRTech | 2.54MM Header | Amazon | 1 | 6.99 | 6.99
 |  |  |  |  |  | 0 |  | 0
L1 | 6.8uH, 3.7A | NRS8040T6R8NJGJ | Taiyo Yuden | Nonstandard SMT | Digikey | 1 | 0.51 | 0.51
 |  |  |  |  |  | 0 |  | 0
Q1 | N-CH, 30V, 20A | NTD20N03L27T4G | On Semi | DPAK | Digikey | 1 | 1.08 | 1.08
Q2, Q4, Q17 | P-CH, 30V, 3.8A | DMP3099L-7 | Diodes Inc. | SOT-23-3 | Digikey | 3 | 0.42 | 1.26
Q3, Q5, Q6, Q7, Q8, Q9, Q12, Q14, Q15, Q18 | N-CH, 30V, 500mA | NTR4003NT3G | ON Semi | SOT-23-3 | Digikey | 10 | 0.29199999999999998 | 2.92
 |  |  |  |  |  | 0 |  | 0
R1, R4, R6, R37, R38, R40, R41, R43, R44, R45, R46, R51, R52, R53, R61, R63, R64 | 10kΩ,, 0.4W | ESR10EZPJ103 | Rohm | 0805 (2012 Metric) | Digikey | 17 | 8.6999999999999994E-2 | 1.4789999999999999
R2 | 2Ω, 1%, 20W | PF1262-2RF1 | Riedon | TO126 | Digikey | 1 | 3.04 | 3.04
R3, R35, R47, R48, R49, R59 | 10Ω, 5%, 2/5W | ESR10EZPJ100 | Rohm | 0805 (2012 Metric) | Digikey | 6 | 0.1 | 0.60000000000000009
R5, R8, R9 | 10mΩ, 1%, 1W | WSLP0805R0100FEA18 | Vishay Dale | 0805 (2012 Metric) | Digikey | 3 | 1.08 | 3.24
R7 | 100kΩ, 5%, 1/8W | RC0805JR-07100KL | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R10 | 40.2kΩ, 1%, 1/8W | RC0805FR-0740K2L | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R11 | 3.57kΩ, 1%, 1/8W | RC0805FR-073K57L | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R12 | 10.5kΩ, 1%, 1/8W | RC0805FR-0710K5L | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R13 | 7.5kΩ, 1%, 1/8W | RC0805FR-077K5L | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R14 | 11.8kΩ, 1%, 1/8W | RC0805FR-0711K8L | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R15 | 261kΩ, 1%, 1/8W | RC0805FR-07261KL | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R16 | 35.7kΩ, 1%, 1/8W | RC0805FR-0735K7L | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R17 | 681kΩ, 1%, 1/8W | RC0805FR-07681KL | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R18, R21, R24 | 102kΩ, 1%, 1/8W | RC0805FR-07102KL | Yageo | 0805 (2012 Metric) | Digikey | 3 | 0.1 | 0.30000000000000004
R19 | 107kΩ, 1%, 1/8W | RC0805FR-07107KL | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R20, R23 | 41.2kΩ, 1%, 1/8W | RC0805FR-0741K2L | Yageo | 0805 (2012 Metric) | Digikey | 2 | 0.1 | 0.2
R22, R25, R29, R32 | 10.2kΩ, 1%, 1/8W | RC0805FR-0710K2L | Yageo | 0805 (2012 Metric) | Digikey | 4 | 0.1 | 0.4
R26 | 75kΩ, 1%, 1/8W | RC0805FR-0775KL | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R27 | 13.7kΩ, 1%, 1/8W | RC0805FR-0713K7L | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R28 | 18.7kΩ, 1%, 1/8W | RC0805FR-0718K7L | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R30, R33 | 43.2kΩ, 1%, 1/8W | RC0805FR-0743K2L | Yageo | 0805 (2012 Metric) | Digikey | 2 | 0.1 | 0.2
R31, R34 | 15kΩ, 1%, 1/8W | RC0805FR-0715KL | Yageo | 0805 (2012 Metric) | Digikey | 2 | 0.1 | 0.2
R36, R54 | 1.2kΩ, 5%, 1/8W | RC0805FR-071K2L | Yageo | 0805 (2012 Metric) | Digikey | 2 | 0.1 | 0.2
R39, R55 | 100Ω, 5%, 1/8W | RC0805JR-07100RL | Yageo | 0805 (2012 Metric) | Digikey | 2 | 0.1 | 0.2
R42, R57 | 150Ω, 5%, 1/8W | RC0805JR-07150RL | Yageo | 0805 (2012 Metric) | Digikey | 2 | 0.1 | 0.2
R50 | 0, 1/8W | RC0805JR-070RL | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R60 | 330Ω, 5%, 1/8W | RC0805JR-07330RL | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
R62 | 910Ω, 5%, 1/8W | RC0805JR-07910RL | Yageo | 0805 (2012 Metric) | Digikey | 1 | 0.1 | 0.1
 |  |  |  |  |  | 0 |  | 0
SW1, SW3 | TACTILE SPST-NO 0.05A 12V | PTS645SM43SMTR92 LFS | C & K | Nonstandard SMT | Digikey | 2 | 0.16 | 0.32
SW2, SW4 | SWITCH SLIDE DPDT 5A 120V | 500SDP1S1M2QEA | E-Switch | Throuh Hole | Digikey | 2 | 3.55 | 7.1
 |  |  |  |  |  | 0 |  | 0
U1 | Dual Power Monitor | LTC2992IDE#PBF | Linear Tech | 16-DFN (4x3) | Digikey | 1 | 9.64 | 9.64
U2, U3 | Adjustable 1.5A LDO | AZ2117H-ADJTRG1 | Diodes Inc. | SOT-223 | Digikey | 2 | 0.4 | 0.8
U4 | Switching Regulator | LT8609EMSE#PBF | Linear Tech | 10-TFSOP, 10-MSOP | Digikey | 1 | 5.46 | 5.46
U5 | Teensy 3.6 | TEENSY36 | PJRC | DIP | PJRC | 1 | 29.95 | 29.95
U6 | IMU + Magnetometer | LSM9DS1TR | ST Micro | Nonstandard SMT | Digikey | 1 | 6.33 | 6.33
U7 | Temp/Pressure/Humidity Sensor | BME280 | Bosch | 8-LGA | Digikey | 1 | 7.56 | 7.56
U8 | MCU 16BIT 256KB FRAM | MSP430FR5994IPNR | T.I. | 80LQFP | Digikey | 1 | 7.89 | 7.89
U10, U11, U12 | TVS DIODE 2.5VWM 5VC | AOZ8318DI | A & O Semi | 10DFN | Digikey | 3 | 0.91 | 2.73
 |  |  |  |  |  | 0 |  | 0
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
## KiCad design PCB/CenterBoard/CenterBoard.kicad_pcb

Parts:
C1: 10000pF; C_0805_HandSoldering
C2, C3: 0.1uF; C_0805_HandSoldering
J1: Input; CONN_8Pin_Molex_Horizontal_SMT
MH1, MH2: Mounting_Hole_Eighth_Inch
R1: 10; C_0805_HandSoldering
U1: LSM9DS1; PQFN24P43_350X300X102L35X23N

Connections:
+3.3V: J1.1, R1.2
GND: C1.2, C2.2, C3.2, J1.5, MH1.1, MH2.1, U1.14 (RES), U1.15 (RES), U1.16 (RES), U1.17 (RES), U1.18 (RES), U1.19 (GND), U1.20 (GND)
IMU_CS_AG: J1.7, U1.7 (CS_A/G)
IMU_CS_M: J1.6, U1.8 (CS_M)
IMU_MISO: J1.8, U1.5 (SDO_A/G), U1.6 (SDO_M)
IMU_MOSI: J1.4, U1.4 (SDA/SDI/SDO)
IMU_SCLK: J1.3, U1.2 (SCL/SPC)
LSM_C1: C3.1, U1.24 (C1)
LSM_CAP: C1.1, U1.21 (CAP)
unnamed: C2.1, R1.1, U1.1 (VDDIO), U1.3 (VDDIO), U1.22 (VDD), U1.23 (VDD)

Board: 2 copper layers, 40.0 x 40.0 mm, 8 parts (0 on the bottom side), 10 nets.

## Commit log

2017-09-02 Added Resources
2017-09-02 Set up file structure
2017-11-15 Teensy 3.6 Psuedo Code
    Original Psuedo Code for Teensy was added, and new folder directory was created.
2017-11-20 Updates to Teensy Code
    1. Teensy folder restructured.
    2. File Structure Set Up.
    3. Psuedo Code put in.
    4. Initliazation of GPIO.
    5. On board LED, as well as blue LED on PCB are toggled to act as a heartbeat.
2017-11-22 Update to Initilization Code
    The following functionality was added:
    1) RTC Initilized. Set to the current date (needs to be manually entered) and the hour minutes and seconds are all intialized to 0.
    2) SD Card Initilization. The interface with the card is initilized and a file is created on the card called HABIP.txt. This file is given a header that contains the date.
    3) A simple Self Test is run on the RTC as well as the SD card. The RTC ST is making sure the clock got set to the desired time. The SD Card Self Test is to make sure that the created file can be acc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
    4) If the SD card does not initilize it will be retried. If the reaction wheel is not enabled, the only function
2017-12-01 Updates to Initialization Code
    LED is blinked three times quickly to show user SD card is not working.
    I2C Initiliazation is setup. Verified correct address and R/W commands were being TXd. Without any of the components we cannot verify it is working, because we don't get an
    acknowledge byte back.
    A RX interrupt still needs to be setup.
    Pins for motor control are setup.
    PWM is setup and verified.
2017-12-06 Updates to initialization code
    ADC Initialization was implemented and successfully tested.
    A calibration of the unit is performed and the Successfull/Not Successful is determined based off of the cal results.
    The ISR has not yet been integrated.
    Frequency of PWM signal was changed to 75Hz. This allows for more varience in the PW.
    SPI has been initialized. Nothing has been tested yet, this still needs to be done. Interrupts need to be set up.
2018-01-23 SPI Bus to IMU Working
    ADC Interrupt Setup
    SPI transmitting to IMU verified.
    Self Test added where SPI will write to IMU "WHO_AM_I" register. If the correct response is heard back, it will mark it as a pass.
    Right now requests are being made for the IMU data, but nothing is being recorded.
    The IMU read function is set up to read from either of the two chips. The chip select is an input to the function.
    The IMU that we currently have was wired as an IMU0 and then as an IMU1. It was verified that we are able to talk to it in either configuration.
2018-01-26 IMU SPI Updates
    Added timeout on SPI transactions. 1ms timeout
    Right now I'm setting a flag that says a timeout happened, but not actually doing anything with that flag. This functionality needs to be added.
    Added Data Write function for SPI0
    Data coming back from the IMU is not being handled right now. Matt C. is going to look into how the data needs to be handled. This will probably be a couple versions from now.
    It is verified that everything on the IMU is being enabled and that the data coming back changes once the IMU is moved around.
2018-01-29 Updates to SD Card Logging, RTC logging
    Version 7:
    Added function to get the current time from the RTC. It populates an array as [sec, min, hr, day, month, year]
    Added Data Write function to the SD Card
    Added New line write function to the data card.
    Right now I have it working where it prints all of the data on one line with one timestamp for all 6 IMU data pieces.
    Each set of 6 reads/write takes approximately 60ms, so one time stamp is fine for this.
2018-01-31 Updates to SD Card, SPI0 bus, and IMU
    Made DataNotValid a global variable so that it can be checked anywhere.
    Made SD Card file comma seperated
    Added IMU Select. If IMU0 passes initialization it will gather data from that. If it fails initialization it will gather data from IMU1.
    Added check for SPI0 timeout. It will print an error message on the SD card as well as reinitialize the SPI bus.
    Added Twos Compliment calculation for all the IMU data. With the two's compliment done, the reads/writes take 20ms.
    Change file type on SD Card to .csv
2018-02-04 Components Placed - Needs Routing and TPs
2018-02-07 Integrated Motor Algorithim
    Added functions to turn motor on/off
    Started reaction wheel algorithim. Only going to do LSB conversions for Z-Gyro when the reaction wheel is running. Otherwise its using recources that we don't need to use. Data is captured and then c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
    Took out the two's compliment function. Now when the data comes back from the IMU it's being placed into a 16 bit short instead of a 32 bit int. Because it's in the 16 bit short the compiler recogniz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
    A button will be used in order to determine if a calibration of the IMU is to be done. This button needs to be held down on startup in order
2018-02-10 Updates to SD Card logging when motor is on
    In order to make the motor controller algorithim run as efficiently as possible, the manner in which SD card writes is done is going to be chagned (only for while the motor is on). The opening and cl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
    As a result the file will be opened once upon entering the loop, closed once upon leaving the loop, and the buffer will be cleared after all six of the IMU write
2018-02-10 Layout Done - Needs TPs Still
2018-02-12 Board Completed. Needs Review
2018-02-13 Updated a couple nets to the proper voltage and re-plotted the schematic
2018-02-15 I2C Functionality Added
    Uploaded on 02/15/2018
    Added initialization for I2C
    Added Write Function for I2C
    Added Read Function for I2C
    The come up for the sensor is the following process:
    1) Initialize pins
2018-02-16 Temperature/Pressure Sensor Read/Write
    Added temp/pressure read every second
    Added temperature calibration data read on startup
    Added pressure calibration read on startup
    The writes to the SD card were added.
    The writes for temperature and pressure sensors take a really long time due to their size. As a result the motor on method is used in order to keep it in a reasonable time window. The card is opened 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
    Read/Write are also added for when motor is on.
2018-02-21 Added BOM, Couple Fixes, Couple Misc Documents
2018-02-21 ADC Working
    A loop was added so that the motor algorithim is run 8 times in between reads and writes. This includes a 10ms delay. This delay can be taken back out if other functionality needs to be added. This k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
    In order to read from all nine battery cells both ADC modules will be used. The initialization was added to intialize both of them. The isr was set up for the second ADC module, and a switch statemen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
    Added SD Card w
2018-02-23 Multiple SD Card Files
    A series of SD card files were added. Because they need to be of type const char* they were hardcoded in an array. It is set up so that a new file can be added every 5 minutes for 4 hours. After it a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
    The file number that we are on is written to non-volitiale memory. This is done so that if we lose power we don't overwrite the data that is already written
    The RTC is checked on startup to see if it is already initialized. This is done in case the teensy loses power but the RTC does not. If this is the case the old RTC values are used.
2018-02-23 Added Teensy Spreadsheet
    A spreadsheet was added that is used to decode the data that is coming back from the Teensy. If the data is copied and pasted from the SD card into this spreadsheet it will automatically calculate ev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
2018-02-27 Current Sensor Added, Miscellaneous Updates
    Added a check where the user can press the button in order to restart the file system. If the button is pressed before the LED starts to flash the calibration on the IMU will be performed. If the but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
    The file names were shortened from HABIP#.csv to H#. This was done in order to save on RAM.
    Added a function to display the results of the Self test on the LEDs. A boolean array was added to store the results. The array is formatted as follows:
    [Current Sensor, ADC0, ADC1, DAQCS
2018-03-13 Added SPI to MSP430
    Added SPI Interface with the MSP430.
    Messages are parsed and data is formatted to be sent out. Everything is done inside the ISR, because a request from the MSP430 can come at any point in time.
    This was tested using a test bench constructed in a seperate Visual Studio file. The MSP430 code has not yet been written, and so this was the only method to test.
    The functionality of the algorithim was verified, but the functonality of the SPI slave configuration cannot be verified until the MSP430 code has been written.
2018-03-20 Some main board fixes, added center board, developing MSP430 code
2018-03-21 Miscellanious Updates found in Testing and Integration
    Changed the way SD files are named. const_cast<char*> is now used to convert from a char* to a const char*, that way the file name can be created on the fly.
    The new format of file names are hhmmss.csv. This works as a timestamp
    According to the schematic the addresss should be 6F because both pins should be grounded. It seems like one of the pins is actually not connected, and so the address is actually 0x6E. If the pin is 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
    Updated so that IMU1 is the default IMU (the one that's centered around the motor) and if it fails then IMU0 is used.
    A retry was added on the calibrat
2018-03-27 SPI with DAQCS Board
    A derivative was added to the controller, making it a PID instead of a PI. The values are now kp = 120, ki = 0.2, kd = 0.01. Testing with the current setup (Two PCBs the arduino board, the motor cont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
    A delay was added after the write to the motor of 50ms. It was found that writing too fast caused problems. We were writing at a rate significantly faster than the mechanical time constant, and this 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
    The SPI is added but IT IS NOT WORKING. The algorithim an
2018-04-04 Updates for Launch
    Some of the launch day patches were added. This includes using the altitude to check for 40,000 feet and 10,000 feet. It triggers a cutdown at three hours and 40,000 feet. The motor turns on at eithe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
    There is a problem with the RTC losing power. We thought using a super cap would be enough to keep it going, but that doesn't seem to be enough. As a result I am
2018-04-30 Imagine/Launch functionality added
    This functionality is only for imagine, and the patched launch. This should not be neccessary if you are going to have a working comms board.
2018-05-01 Teensy User Guide
    Teensy User Guide was created
2023-10-28 Updated files and organization
